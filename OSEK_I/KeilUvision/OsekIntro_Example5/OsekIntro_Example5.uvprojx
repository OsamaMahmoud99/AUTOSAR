# Keil uVision project OsekIntro_Example5.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OsekIntro_Example1
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\oil;..\..\OsekLib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source group1
    ../../OsekLib/: hook.c counter.c counter.h os.h OsekLib.lib OsTypes.h
    ../../OsekLib/startup/: keilUvisoin_startup.s
    ./: tm4c123gh6pm.h driverlib.lib OsekIntro_Example5.c
    ../../oil/: OsCfg.c OsCfg.h
software components: CMSIS:CORE 5.4.0
